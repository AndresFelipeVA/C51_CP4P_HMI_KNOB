# Keil uVision project template.uvproj, settings and files
target TEMPLATE (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: 1.bat
  c flags: Optimize=3
  c include: ..\USER;..\FUNC_HANDLER;..\GUI_APP
  link misc: REMOVEUNUSED
  group USER
    ./: STARTUP_M5.A51 main.c encoder.c ui.c sys.c uart.c timer.c
